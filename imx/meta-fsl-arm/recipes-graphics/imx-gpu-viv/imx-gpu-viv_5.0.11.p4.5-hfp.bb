# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-gpu-viv.inc

S="${WORKDIR}/${PN}-${PV}"

SRC_URI[md5sum] = "e7c0185ab2ae0320cb7c0a1a479b6749"
SRC_URI[sha256sum] = "839422910faa07514f443cca345cc8c72d1a2863b2e5bf9c6eb1c3c69525279b"

PACKAGE_FP_TYPE = "hardfp"
