# Copyright (C) 2015 Freescale Semiconductor

require imx-gpu-viv-kernel.inc
          
SRC_URI[md5sum] = "5c15bb77fc55eda675c5a18a8186371d"
SRC_URI[sha256sum] = "c15bab5a142f5fa95a55ed83386b4f7d057049f15f0e82080502786650640fee"

S = "${WORKDIR}/${PN}-${PV}"
