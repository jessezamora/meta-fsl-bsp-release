require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "de42298011f8a40f9bc68396e2e7d7bd"
SRC_URI[sha256sum] = "84cdb604cc6233bcaff235c4b4995b0c4f6174545e5e4f72b760752380a39b6d"

COMPATIBLE_MACHINE = "(mx8)"
