require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d" 

SRC_URI[md5sum] = "bf5dd196fc712e05316b522a5d0f5130"
SRC_URI[sha256sum] = "4fd4faa13fe6938e67c205fc5edae15e1fceeb14f1f0480afcd9ef8515932c38"

COMPATIBLE_MACHINE = "(mx8)"
