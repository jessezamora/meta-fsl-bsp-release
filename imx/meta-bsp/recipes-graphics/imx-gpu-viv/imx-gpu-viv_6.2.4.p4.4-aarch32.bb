require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3"

SRC_URI[md5sum] = "8af42030d5a0d1e0eb5ee48182616c42"
SRC_URI[sha256sum] = "7b891588529a3aabf5f79ab6dfb9ad2f5c297ea75ebcc07bc55c376fc83af567"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
