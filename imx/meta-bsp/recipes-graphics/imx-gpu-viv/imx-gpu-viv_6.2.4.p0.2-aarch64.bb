require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "c250d5bbcb0594f3cddb8ed3993fca76"
SRC_URI[sha256sum] = "b156159101fc84aa7e9f48605bcc3471e70d21f4a7246e1aa711577f856ced5c"

COMPATIBLE_MACHINE = "(mx8)"
