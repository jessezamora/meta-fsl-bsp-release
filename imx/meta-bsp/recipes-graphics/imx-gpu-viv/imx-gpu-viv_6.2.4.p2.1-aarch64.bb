require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "b0e2c66b26c9b7f61ceefcdcf5dd284c"
SRC_URI[sha256sum] = "257050be4d7bf2994ebee6674172d18217b0dd210bca45ed4ca08cdf583b6d19"

COMPATIBLE_MACHINE = "(mx8)"
