require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d" 

SRC_URI[md5sum] = "4f1d7e74643a4df232b4b6717f872363"
SRC_URI[sha256sum] = "3efe9190cb7dfa983e6d59fc952e3d352e13cf4ebb3496c2aea20817f5f10437"

COMPATIBLE_MACHINE = "(mx8)"
