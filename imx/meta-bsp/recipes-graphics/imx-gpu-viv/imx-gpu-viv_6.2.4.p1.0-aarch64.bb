require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "ac9729c9ad42efff177e7b9382dcf38f"
SRC_URI[sha256sum] = "aa4f2b02b63681b4db4f5a12e90fc7021117b770d4720c63de2d0d34c40425d7"

COMPATIBLE_MACHINE = "(mx8)"
