require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "ab60329b229b385e4caba215d742ce2e"
SRC_URI[sha256sum] = "0cd7e6aace50fe54c6d5d7cd8b8abbaf96d95a95bb8ac54353aa26054dd25e79"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
