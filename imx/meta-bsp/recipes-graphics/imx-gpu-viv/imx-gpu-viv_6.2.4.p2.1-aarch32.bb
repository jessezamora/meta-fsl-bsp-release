require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "2a9f225c1684208cdd6416091c358ee6"
SRC_URI[sha256sum] = "15e04d83656235858221084238c8ffd0687da00f51a36f891d65df8799397678"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
