require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3" 

SRC_URI[md5sum] = "8c5c0dd971a5944e5517186f9e58038b"
SRC_URI[sha256sum] = "a3214a37fb0c5c7d0fa297c8b0d590b26146f87851946af42104ee1b363926ff"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
