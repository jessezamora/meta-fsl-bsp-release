require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=1b4db4b25c3a1e422c0c0ed64feb65d2"

SRC_URI[md5sum] = "6a2767b060914cf76dd56af9ec899fcf"
SRC_URI[sha256sum] = "2190d39f03ad5ab88e978d3f9059e28b3bf4cb6c34b6ae74e7bd1c8d95e53edb"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
