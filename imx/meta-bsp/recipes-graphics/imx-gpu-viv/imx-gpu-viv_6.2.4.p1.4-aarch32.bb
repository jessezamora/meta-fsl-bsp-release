require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "bc8cad99ab4e18e9a64f55b41bfd9e34"
SRC_URI[sha256sum] = "9207b44f1ab4a179a77652d9b07b13538256300d77c9a2bc9f4a577b0888ce48"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
