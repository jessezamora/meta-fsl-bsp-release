require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3" 

SRC_URI[md5sum] = "76e6dd7dd23dcefc5548f89fd6eaac26"
SRC_URI[sha256sum] = "5f2023953becefd3969af8b39e12701e8081358a28eeb8c154634953134a67bb"

COMPATIBLE_MACHINE = "(mx8)"
