require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "3ee4b8776743760c1ef61aab85c7a233"
SRC_URI[sha256sum] = "7514e1183c1821c3da100ce08fbd89055b72114db3bd6ad480b5beb6217928dd"

COMPATIBLE_MACHINE = "(mx8)"
