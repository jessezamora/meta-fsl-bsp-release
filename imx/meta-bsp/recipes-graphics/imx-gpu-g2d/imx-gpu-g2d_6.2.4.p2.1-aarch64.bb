require imx-gpu-g2d.inc

SRC_URI[md5sum] = "42c0ec38efb5576c9b76489668410a9c"
SRC_URI[sha256sum] = "cc3585c02841027606466e45fb387d7276eeeccc08d855642204bb0218339df7"
