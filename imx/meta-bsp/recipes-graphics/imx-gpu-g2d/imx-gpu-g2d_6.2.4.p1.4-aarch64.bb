require imx-gpu-g2d.inc

SRC_URI[md5sum] = "d426f3f34f812c3c77e40228b8a7e12d"
SRC_URI[sha256sum] = "42bdd1218e9c8fc5591dd2611b444dcf72d9cce8c91f6629325f43c1ae38b4a3"

COMPATIBLE_MACHINE = "(mx8mm)"