require imx-gpu-g2d.inc

SRC_URI[md5sum] = "84ddfced6783881a1e293a94d52e3504"
SRC_URI[sha256sum] = "224578cc537b7319890b5ecf8fa2ee5203a636739193094b7be1ed411dd5a0ef"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
