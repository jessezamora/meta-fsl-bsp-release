require imx-gpu-g2d.inc

SRC_URI[md5sum] = "9ce0b7f5659f912cd9010df6d1dc35ca"
SRC_URI[sha256sum] = "685c5afb3e069e158c327398ba5f958ae01a669ef1ccf52f5b58051a768737ee"
