APITRACE_SRC ?= "git://github.com/nxp-imx/apitrace-imx.git;protocol=https"
SRCBRANCH = "imx_7.1"
SRC_URI = "${APITRACE_SRC};branch=${SRCBRANCH}"
SRCREV = "09579e67262af9c993dd082055a924c2c61cf34d"
