require recipes-kernel/kernel-modules/kernel-module-imx-gpu-viv_6.2.4.p1.8.bb

LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"
SRCBRANCH = "imx_4.19.35_1.1.0"
SRCREV = "9e9129353eceff8890ce12673821e46e12d6cade"

LOCALVERSION = "-1.1.0"
