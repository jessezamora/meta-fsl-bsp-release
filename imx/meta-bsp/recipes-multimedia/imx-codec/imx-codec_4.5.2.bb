# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3" 

SRC_URI[md5sum] = "cd6db7006eb54b5d05219afdb730455d"
SRC_URI[sha256sum] = "15301708276dae6da40e2e5414f0fcd4e436f527ae0f10cc5ae59c689d24b85a"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
