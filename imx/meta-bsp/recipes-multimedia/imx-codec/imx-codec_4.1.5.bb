# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=be67a88e9e6c841043b005ad7bcf8309"

SRC_URI[md5sum] = "4abe52b613b6c466afe1b57307aaa057"
SRC_URI[sha256sum] = "c7c05c55cf1f487da5995cd19422de1c8cff151ee69a465fef9d4b01e8b9bba1"

COMPATIBLE_MACHINE = "(mx6|mx6ul|mx6sll|mx7|mx8)"
