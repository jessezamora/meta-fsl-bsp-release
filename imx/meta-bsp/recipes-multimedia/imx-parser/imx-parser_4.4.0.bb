# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=75abe2fa1d16ca79f87cde926f05f72d"

SRC_URI[md5sum] = "abad166d45e340850e8bda859ce2ce66"
SRC_URI[sha256sum] = "a71536e16c41ed712d3add161b06542f75a0074f3d0b766eba7ba05317defd70"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
