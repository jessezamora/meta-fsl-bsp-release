# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5ab1a30d0cd181e3408077727ea5a2db"

SRC_URI[md5sum] = "51e61940d772e29d347d8b09501010e2"
SRC_URI[sha256sum] = "92083d249b7566e1347c855d1a84d01fee17d2f96e665b07a65a00191b4494d6"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
