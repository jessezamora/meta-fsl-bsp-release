SRC_URI = "git://gitorious.org/qt-in-use/qt-in-industrial-embedded.git;protocol=https"
