SOC_GPU_TOOLS_X11_append_mx7ulp  = " eglinfo-x11 gtkperf glcompbench"
SOC_GPU_TOOLS_FB_mx7ulp  = "eglinfo-fb"
SOC_GPU_TOOLS_WAYLAND_mx7ulp  = "mesa-demos glmark2"
SOC_GPU_TOOLS_XWAYLAND_mx7ulp  = "mesa-demos gtkperf glmark2"

OPENCV_TOOLS_INSTALL_append_mx7ulp = "opencv-apps opencv-samples opencv-data"
