COMPATIBLE_MACHINE_mx7ulp  = "(-)"
