
SRC_URI_append_mx7ulp = " \
    file://new_egl_header.patch \
"